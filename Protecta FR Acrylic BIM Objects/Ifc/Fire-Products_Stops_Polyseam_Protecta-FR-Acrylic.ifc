Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Fire-Products_Stops_Polyseam_Protecta-FR-Acrylic.ifc
Time: 2021-05-05T05:29:51
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcProxy, Protecta FR Acrylic
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Protecta FR Acrylic; SKU (BO_prodsku): Protecta_FR_Acrylic; ManufacturName (BO_Manufac): Polyseam; BrandUrl (BO_brandurl): https://www.polyseam.com/polyseam_en/; ProductFamily (BO_prodfam): Protecta; ProductGroup (BO_prodgroup): FR Acrylic; ManufacturCountry (BO_mancont): United Kingdom; DesignCountry (BO_designcont): United Kingdom; PublishDate (BO_publisdat): 3/17/2020; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/polyseam/product/Protecta_FR_Acrylic; ProductDataUrl (BO_prodaturl): bimobject.com/polyseam/product/Protecta_FR_Acrylic; ProductUrl (BO_producturl): https://www.polyseam.com/protecta/protecta_en/fr-acrylic.html; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=6WravBUPRyg&list=PU_zqB7qa43wpO94l4hHkepw&index=12; GtinCode (BO_gtin): 7030020715025; BimObjectMainCategory (BO_bomaincat): Fire Products; BimObjectMainCategoryCode (BO_bomaincat_code): fire-products; BimObjectCategory (BO_bocat): Stops; BimObjectCategoryCode (BO_bocat_code): fire-stops; IfcClassification (BO_ifcclas): Object; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
